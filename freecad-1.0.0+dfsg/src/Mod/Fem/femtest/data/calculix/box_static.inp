** written by FreeCAD inp file writer for CalculiX,Abaqus meshes
** highest dimension mesh elements only.

** Nodes
*Node, NSET=Nall
1, 0, 0, 0
2, 0, 0, 10
3, 0, 10, 0
4, 0, 10, 10
5, 10, 0, 0
6, 10, 0, 10
7, 10, 10, 0
8, 10, 10, 10
9, 0, 0, 5
10, 0, 0, 2.5
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

** Volume elements
*Element, TYPE=C3D10, ELSET=Evolumes
1, 95, 98, 47, 196, 103, 197, 198, 200, 199, 201
2, 147, 121, 145, 196, 203, 202, 161, 205, 204, 206
3, 73, 70, 27, 121, 84, 80, 83, 208, 207, 136
4, 72, 170, 30, 171, 209, 187, 75, 210, 181, 194
5, 9, 98, 47, 95, 101, 197, 54, 102, 103, 198
6, 172, 70, 30, 71, 211, 78, 186, 212, 93, 91
7, 170, 99, 36, 174, 213, 119, 184, 191, 214, 190
8, 12, 47, 149, 145, 57, 215, 150, 152, 216, 155
9, 70, 27, 123, 72, 80, 143, 217, 79, 77, 218
10, 39, 147, 121, 145, 160, 203, 132, 159, 161, 202
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
** Define element set Eall
*ELSET, ELSET=Eall
Evolumes


***********************************************************
** Element sets for materials and FEM element type (solid, shell, beam, fluid)
*ELSET,ELSET=MechanicalMaterialSolid
Evolumes

***********************************************************
** constraints fixed node sets
** FemConstraintFixed
*NSET,NSET=FemConstraintFixed
1,
2,
3,
4,
9,
10,
11,
12,
13,
14,
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
** Physical constants for SI(mm) unit system with Kelvins
*PHYSICAL CONSTANTS, ABSOLUTE ZERO=0, STEFAN BOLTZMANN=5.670374419e-11

***********************************************************
** Materials
** see information about units at file end
** FreeCAD material name: Steel-Generic
** MechanicalMaterial
*MATERIAL, NAME=MechanicalMaterial
*ELASTIC
200000,0.3

***********************************************************
** Sections
*SOLID SECTION, ELSET=MechanicalMaterialSolid, MATERIAL=MechanicalMaterial

***********************************************************
** At least one step is needed to run an CalculiX analysis of FreeCAD
*STEP, INC=2000
*STATIC


***********************************************************
** Fixed Constraints
** FemConstraintFixed
*BOUNDARY
FemConstraintFixed,1
FemConstraintFixed,2
FemConstraintFixed,3


***********************************************************
** constraints force node loads
*CLOAD
** FemConstraintForce
** node loads on shape: Box:Face6
2,3,-0
4,3,-0
6,3,-0
8,3,-0
18,3,-0
19,3,-833.3333333333
20,3,-833.3333333333
30,3,-0
31,3,-833.3333333333
32,3,-833.3333333333
36,3,-0
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

***********************************************************
** constraints pressure element face loads
** FemConstraintPressure
*DLOAD
** FemConstraintPressure: face load
3,P1,1000.0
6,P3,1000.0
9,P2,1000.0
36,P1,1000.0
38,P1,1000.0
56,P1,1000.0
61,P3,1000.0
67,P2,1000.0
68,P3,1000.0
75,P2,1000.0
76,P4,1000.0
78,P4,1000.0
79,P2,1000.0
90,P3,1000.0
105,P3,1000.0
125,P3,1000.0

***********************************************************
** Outputs --> frd file
*NODE FILE
U
*EL FILE
S, E
** outputs --> dat file
** reaction forces for Constraint fixed
*NODE PRINT, NSET=FemConstraintFixed, TOTALS=ONLY
RF

*OUTPUT, FREQUENCY=1
***********************************************************
*END STEP

***********************************************************
** CalculiX Input file
**   written by    --> FreeCAD 0.21.0
**   written on    --> Tue Mar 28 06:53:21 2023
**   file name     --> box_static.FCStd
**   analysis name --> Analysis
**
**
***********************************************************
**  About units:
**  See ccx manual, ccx does not know about any unit.
**  Golden rule: The user must make sure that the numbers they provide have consistent units.
**  The user is the FreeCAD calculix writer module ;-)
**
**  The unit system which is used at Guido Dhondt's company: mm, N, s, K
**  Since Length and Mass are connected by Force, if Length is mm the Mass is in t to get N
**  The following units are used to write to inp file:
**
**  Length: mm (this includes the mesh geometry)
**  Mass: t
**  TimeSpan: s
**  Temperature: K
**
**  This leads to:
**  Force: N
**  Pressure: N/mm^2 == MPa (Young's Modulus has unit Pressure)
**  Density: t/mm^3
**  Gravity: mm/s^2
**  Thermal conductivity: t*mm/K/s^3 == as W/m/K == kW/mm/K
**  Specific Heat: mm^2/s^2/K = J/kg/K == kJ/t/K
**
